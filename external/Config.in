## external/package/ioctl-driver/Config.in
```kconfig
config BR2_PACKAGE_IOCTL_DRIVER
	bool "ioctl-assignments"
	help
	  Compile .ko and application to be loaded
```
